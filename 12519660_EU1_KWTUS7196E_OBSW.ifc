Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 880f82c4-199e-41b5-bb39-b3600ecfcc32, NumberOfSaves: 1]
File name: 0001
Time: 2026-01-14T06:52:49+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12519660_EU1_KWTUS7196E_OBSW:39719610_EU1_12519660_KWTUS7196E_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, Spruce, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Cast, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 859 mm; Depth: 579 mm
Pset_BuildingElementProxyCommon - Reference: 39719610_EU1_12519660_KWTUS7196E_OBSW; sets with these values: 2
